SRC_URI_append ="\
    file://system-user.dtsi \
    file://openamp-overlay.dtsi \
"
FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
